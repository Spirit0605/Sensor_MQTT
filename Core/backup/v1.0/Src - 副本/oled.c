#include "oled.h"
#include <string.h>

#define OLED_ADDR (0x3C << 1)

static I2C_HandleTypeDef *oled_i2c;
static uint8_t oled_buf[OLED_WIDTH * OLED_HEIGHT / 8];

/* 5x7 字模：每个字模占 5 字节，每位代表一个像素行 */
static const uint8_t font[][5] = {
    /* 0-9 */
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, /* 0 */
    {0x00, 0x42, 0x7F, 0x40, 0x00}, /* 1 */
    {0x42, 0x61, 0x51, 0x49, 0x46}, /* 2 */
    {0x21, 0x41, 0x45, 0x4B, 0x31}, /* 3 */
    {0x18, 0x14, 0x12, 0x7F, 0x10}, /* 4 */
    {0x27, 0x45, 0x45, 0x45, 0x39}, /* 5 */
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, /* 6 */
    {0x01, 0x71, 0x09, 0x05, 0x03}, /* 7 */
    {0x36, 0x49, 0x49, 0x49, 0x36}, /* 8 */
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* 9 */

    /* A-Z */
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* A */
    {0x7F, 0x49, 0x49, 0x49, 0x36}, /* B */
    {0x3E, 0x41, 0x41, 0x41, 0x22}, /* C */
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, /* D */
    {0x7F, 0x49, 0x49, 0x49, 0x41}, /* E */
    {0x7F, 0x09, 0x09, 0x09, 0x01}, /* F */
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, /* G */
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, /* H */
    {0x00, 0x41, 0x7F, 0x41, 0x00}, /* I */
    {0x20, 0x40, 0x41, 0x3F, 0x01}, /* J */
    {0x7F, 0x08, 0x14, 0x22, 0x41}, /* K */
    {0x7F, 0x40, 0x40, 0x40, 0x40}, /* L */
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, /* M */
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, /* N */
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, /* O */
    {0x7F, 0x09, 0x09, 0x09, 0x06}, /* P */
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, /* Q */
    {0x7F, 0x09, 0x19, 0x29, 0x46}, /* R */
    {0x46, 0x49, 0x49, 0x49, 0x31}, /* S */
    {0x01, 0x01, 0x7F, 0x01, 0x01}, /* T */
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, /* U */
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, /* V */
    {0x3F, 0x40, 0x38, 0x40, 0x3F}, /* W */
    {0x63, 0x14, 0x08, 0x14, 0x63}, /* X */
    {0x07, 0x08, 0x70, 0x08, 0x07}, /* Y */
    {0x61, 0x51, 0x49, 0x45, 0x43}, /* Z */

    /* a-z */
    {0x20, 0x54, 0x54, 0x54, 0x78}, /* a */
    {0x7F, 0x48, 0x44, 0x44, 0x38}, /* b */
    {0x38, 0x44, 0x44, 0x44, 0x20}, /* c */
    {0x38, 0x44, 0x44, 0x48, 0x7F}, /* d */
    {0x38, 0x54, 0x54, 0x54, 0x18}, /* e */
    {0x08, 0x7E, 0x09, 0x01, 0x02}, /* f */
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, /* g */
    {0x7F, 0x08, 0x04, 0x04, 0x78}, /* h */
    {0x00, 0x44, 0x7D, 0x40, 0x00}, /* i */
    {0x20, 0x40, 0x44, 0x3D, 0x00}, /* j */
    {0x7F, 0x10, 0x28, 0x44, 0x00}, /* k */
    {0x00, 0x41, 0x7F, 0x40, 0x00}, /* l */
    {0x7C, 0x04, 0x18, 0x04, 0x78}, /* m */
    {0x7C, 0x08, 0x04, 0x04, 0x78}, /* n */
    {0x38, 0x44, 0x44, 0x44, 0x38}, /* o */
    {0x7C, 0x14, 0x14, 0x14, 0x08}, /* p */
    {0x08, 0x14, 0x14, 0x18, 0x7C}, /* q */
    {0x7C, 0x08, 0x04, 0x04, 0x08}, /* r */
    {0x48, 0x54, 0x54, 0x54, 0x20}, /* s */
    {0x04, 0x3F, 0x44, 0x40, 0x20}, /* t */
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, /* u */
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, /* v */
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, /* w */
    {0x44, 0x28, 0x10, 0x28, 0x44}, /* x */
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, /* y */
    {0x44, 0x64, 0x54, 0x4C, 0x44}, /* z */

    /* : */
    {0x00, 0x36, 0x36, 0x00, 0x00}  /* : */

};

static HAL_StatusTypeDef OLED_WriteCmd(uint8_t cmd)
{
    uint8_t data[2] = {0x00, cmd};

    return HAL_I2C_Master_Transmit(
        oled_i2c, OLED_ADDR, data, 2, 100);
}

HAL_StatusTypeDef OLED_Init(I2C_HandleTypeDef *hi2c)
{
    oled_i2c = hi2c;

    HAL_Delay(100);

    /* SSD1306 初始化：128x64，I2C，内部电荷泵 */
    const uint8_t init_cmds[] = {
        0xAE,       /* 关闭显示 */
        0xD5, 0x80, /* 时钟分频 */
        0xA8, 0x3F, /* 复用率：64行 */
        0xD3, 0x00, /* 显示偏移 */
        0x40,       /* 起始行 */
        0x8D, 0x14, /* 开启内部电荷泵 */
        0x20, 0x02, /* 页寻址模式 */
        0xA1,       /* 段重映射 */
        0xC8,       /* COM扫描方向 */
        0xDA, 0x12, /* COM引脚配置 */
        0x81, 0xCF, /* 对比度 */
        0xD9, 0xF1, /* 预充电周期 */
        0xDB, 0x40, /* VCOMH */
        0xA4,       /* 显示显存内容 */
        0xA6,       /* 正常显示，非反色 */
        0xAF        /* 开启显示 */
    };

    for (uint16_t i = 0; i < sizeof(init_cmds); i++)
    {
        if (OLED_WriteCmd(init_cmds[i]) != HAL_OK)
            return HAL_ERROR;
    }

    OLED_Clear();
    return OLED_Refresh();
}

void OLED_Clear(void)
{
    memset(oled_buf, 0, sizeof(oled_buf));
}

void OLED_DrawPoint(uint8_t x, uint8_t y, uint8_t color)
{
    if (x >= OLED_WIDTH || y >= OLED_HEIGHT)
        return;

    uint16_t index = x + (y / 8) * OLED_WIDTH;
    uint8_t mask = 1U << (y % 8);

    if (color)
        oled_buf[index] |= mask;
    else
        oled_buf[index] &= (uint8_t)~mask;
}

HAL_StatusTypeDef OLED_Refresh(void)
{
    uint8_t data[129];

    /* 每页 128 字节，前面增加 0x40 数据控制字节 */
    data[0] = 0x40;

    for (uint8_t page = 0; page < 8; page++)
    {
        if (OLED_WriteCmd(0xB0 | page) != HAL_OK)
            return HAL_ERROR;

        if (OLED_WriteCmd(0x00) != HAL_OK)
            return HAL_ERROR;

        if (OLED_WriteCmd(0x10) != HAL_OK)
            return HAL_ERROR;

        memcpy(&data[1],
               &oled_buf[page * OLED_WIDTH],
               OLED_WIDTH);

        if (HAL_I2C_Master_Transmit(
                oled_i2c, OLED_ADDR,
                data, sizeof(data), 100) != HAL_OK)
        {
            return HAL_ERROR;
        }
    }

    return HAL_OK;
}

void OLED_ShowChar(uint8_t x, uint8_t y, char ch)
{
    const uint8_t *p = NULL;

    if (ch >= '0' && ch <= '9')
        p = font[ch - '0'];
    else if (ch >= 'A' && ch <= 'Z')
        p = font[10 + ch - 'A'];
    else if (ch >= 'a' && ch <= 'z')
        p = font[36 + ch - 'a'];      /* 数字10 + 大写26 = 36 */
    else if (ch == ':')
        p = font[62];                 /* 36 + 26 = 62 */
    else if (ch == ' ')
        p = NULL;
    else
        return;

    for (uint8_t col = 0; col < 6; col++)
    {
        uint8_t bits = (p != NULL && col < 5) ? p[col] : 0;

        for (uint8_t row = 0; row < 7; row++)
        {
            OLED_DrawPoint(x + col, y + row,
                           (bits >> row) & 0x01);
        }
    }
}

void OLED_ShowString(uint8_t x, uint8_t y, const char *str)
{
    while (*str != '\0')
    {
        if (x > OLED_WIDTH - 6)
            break;

        OLED_ShowChar(x, y, *str++);
        x += 6;
    }
}
